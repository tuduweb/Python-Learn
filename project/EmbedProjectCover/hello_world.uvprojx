# Keil uVision project hello_world.uvprojx, settings and files
target hello_world ram_0x1400_debug (6100001::V6.10.1::.\ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../Libraries/imxrt1052_Lib/CMSIS/Include;../../Libraries/imxrt1052_Lib/devices/;../../Libraries/imxrt1052_Lib/devices/drivers;../../Libraries/imxrt1052_Lib/utilities/str;../../Libraries/imxrt1052_Lib/utilities/debug_console;../../Libraries/imxrt1052_Lib/components/uart;../../Libraries/imxrt1052_Lib/components/serial_manager;../../Libraries/imxrt1052_Lib/components/lists;../../Libraries/imxrt1052_Lib/drivers;../../Libraries/imxrt1052_Lib/utilities;../../Libraries/imxrt1052_Lib/xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram_0x1400.scf
  link misc: --remove
  group source
    ../: hello_world.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../Libraries/imxrt1052_Lib/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_lpuart.c fsl_lpuart.h fsl_iomuxc.h fsl_gpio.c fsl_gpio.h
  group device
    ../../Libraries/imxrt1052_Lib/devices/: MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../Libraries/imxrt1052_Lib/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../Libraries/imxrt1052_Lib/utilities/str/: fsl_str.c fsl_str.h
    ../../Libraries/imxrt1052_Lib/utilities/: fsl_assert.c
  group component-uart
    ../../Libraries/imxrt1052_Lib/components/uart/: lpuart_adapter.c uart.h
  group component-serial_manager
    ../../Libraries/imxrt1052_Lib/components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../Libraries/imxrt1052_Lib/components/lists/: generic_list.c generic_list.h
  group startup
    ../../Libraries/imxrt1052_Lib/startup/keil/: startup_MIMXRT1052.s
  group xip
    ../../Libraries/imxrt1052_Lib/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h xip_config.c
  group CMSIS
    ../../Libraries/imxrt1052_Lib/CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target norflash (6100001::V6.10.1::.\ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove
