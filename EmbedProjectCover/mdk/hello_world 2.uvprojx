# Keil uVision project hello_world 2.uvprojx, settings and files
target hello_world ram_0x1400_debug (6100001::V6.10.1::.\ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;..\..\Libraries\imxrt1052_Lib\CMSIS\Include;..\..\Libraries\imxrt1052_Lib\devices\;..\..\Libraries\imxrt1052_Lib\devices\drivers;..\..\Libraries\imxrt1052_Lib\utilities\str;..\..\Libraries\imxrt1052_Lib\utilities\debug_console;..\..\Libraries\imxrt1052_Lib\components\uart;..\..\Libraries\imxrt1052_Lib\components\serial_manager;..\..\Libraries\imxrt1052_Lib\components\lists;..\..\Libraries\imxrt1052_Lib\drivers;..\..\Libraries\imxrt1052_Lib\utilities;..\..\Libraries\imxrt1052_Lib\xip;..\..\Libraries\RT10xx_HAL_Driver\;..\..\Libraries\RT10xx_HAL_Driver\Inc;..\..\Libraries\BIN_Peripheral;..\..\Project\Application
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram_0x1400.scf
  link misc: --remove
  group board
    ../: pin_mux.c board.c clock_config.c pin_mux.h board.h clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../Libraries/imxrt1052_Lib/drivers/: fsl_clock.c fsl_common.c fsl_lpuart.c fsl_gpio.c fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_cmp.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_camera.c fsl_flexio_camera_edma.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_mculcd.c fsl_flexio_mculcd_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexram_allocate.c fsl_flexspi.c fsl_gpc.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart_edma.c fsl_ocotp.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_tempmon.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c fsl_clock.h fsl_common.h fsl_lpuart.h fsl_iomuxc.h fsl_gpio.h fsl_adc.h fsl_adc_etc.h fsl_aipstz.h fsl_aoi.h fsl_bee.h fsl_cache.h fsl_cmp.h fsl_csi.h fsl_dcdc.h fsl_dcp.h fsl_dmamux.h fsl_edma.h fsl_elcdif.h fsl_enc.h fsl_enet.h fsl_ewm.h fsl_flexcan.h fsl_flexio.h fsl_flexio_camera.h fsl_flexio_camera_edma.h fsl_flexio_i2c_master.h fsl_flexio_i2s.h fsl_flexio_i2s_edma.h fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.h fsl_flexio_spi.h fsl_flexio_spi_edma.h fsl_flexio_uart.h fsl_flexio_uart_edma.h fsl_flexram.h fsl_flexram_allocate.h fsl_flexspi.h fsl_gpc.h fsl_gpt.h fsl_kpp.h fsl_lpi2c.h fsl_lpi2c_edma.h fsl_lpspi.h fsl_lpspi_edma.h fsl_lpuart_edma.h fsl_ocotp.h fsl_pit.h fsl_pmu.h fsl_pwm.h fsl_pxp.h fsl_qtmr.h fsl_rtwdog.h fsl_sai.h fsl_sai_edma.h fsl_semc.h fsl_snvs_hp.h fsl_snvs_lp.h fsl_spdif.h fsl_spdif_edma.h fsl_src.h fsl_tempmon.h fsl_trng.h fsl_tsc.h fsl_usdhc.h fsl_wdog.h fsl_xbara.h fsl_xbarb.h
  group device
    ../../Libraries/imxrt1052_Lib/devices/: system_MIMXRT1052.c MIMXRT1052.h MIMXRT1052_features.h fsl_device_registers.h system_MIMXRT1052.h
  group utilities
    ../../Libraries/imxrt1052_Lib/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../Libraries/imxrt1052_Lib/utilities/str/: fsl_str.c fsl_str.h
    ../../Libraries/imxrt1052_Lib/utilities/: fsl_assert.c
  group component/uart
    ../../Libraries/imxrt1052_Lib/components/uart/: lpuart_adapter.c uart.h
  group component/serial_manager
    ../../Libraries/imxrt1052_Lib/components/serial_manager/: serial_manager.c serial_port_uart.c serial_manager.h serial_port_internal.h serial_port_uart.h
  group component/lists
    ../../Libraries/imxrt1052_Lib/components/lists/: generic_list.c generic_list.h
  group startup
    ../../Libraries/imxrt1052_Lib/startup/keil/: startup_MIMXRT1052.s
  group xip
    ../../Libraries/imxrt1052_Lib/xip/: fsl_flexspi_nor_boot.c xip_config.c fsl_flexspi_nor_boot.h
  group CMSIS
    ../../Libraries/imxrt1052_Lib/CMSIS/Include/: core_cm7.h cmsis_compiler.h cmsis_version.h mpu_armv7.h cmsis_armclang.h cmsis_armcc.h
  group common
    ../../Libraries/RT10xx_HAL_Driver/Inc/: MIMXRT10xx.h common.h hal_port.h
  group peripheral
    ../../Libraries/bin_peripheral/: BIN_LED.c BIN_MT9V034.c BIN_LED.h BIN_MT9V034.h
    ../../Libraries/BIN_Peripheral/: BIN_CAMERA.h
  group HAL_Drivers
    ../../Libraries/RT10xx_HAL_Driver/: rt10xx_hal_iomuxc.c rt10xx_hal_iic.c rt10xx_hal_iomuxc.h rt10xx_hal_iic.h
  group application
    ../: hello_world.c
  group application/system
    ../Application/: system.c system.h
  group application/process
    ../Application/: TeslaMaster.c PixelMaster.c PixelMaster.h TeslaMaster.h
target norflash (6100001::V6.10.1::.\ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: ..;..\..\Libraries\imxrt1052_Lib\CMSIS\Include;..\..\Libraries\imxrt1052_Lib\devices\;..\..\Libraries\imxrt1052_Lib\devices\drivers;..\..\Libraries\imxrt1052_Lib\utilities\str;..\..\Libraries\imxrt1052_Lib\utilities\debug_console;..\..\Libraries\imxrt1052_Lib\components\uart;..\..\Libraries\imxrt1052_Lib\components\serial_manager;..\..\Libraries\imxrt1052_Lib\components\lists;..\..\Libraries\imxrt1052_Lib\drivers;..\..\Libraries\imxrt1052_Lib\utilities;..\..\Libraries\imxrt1052_Lib\xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove
